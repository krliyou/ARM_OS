# Keil uVision project liyou.uvprojx, settings and files
target liyou (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf  --text  -a -c  --output="$L@L.dis"  "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD
  c include: ..\..\..\..\kernel;.\app;.\drivers\UART;.\board;.\board\Exception\Systick;.\board\Interrupt;.\board\System_Init;.\board\Exception\ErrorHandler;.\board\Register;..\..\..\..\lib\include;.\board\Delay;..\..\..\..\components\shell;..\..\..\..\lib\include;..\..\..\..\lib\list;..\..\..\..\lib\ringbuffer;.\drivers\LED;..\..\..\..\board\arm\cortex-m3;..\..\..\..\..\ARM_OS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group usr
    ./app/: main.c
  group kernel
    ../../../../kernel/: clock.c irq.c scheduler.c task.c timer.c
  group drivers
    ./drivers/UART/: usart_tranfer.c
    ./drivers/LED/: led.c
  group cpu
    ./board/System_Init/: sys.c
    ./board/Interrupt/: Nvic_config.c Exti_config.c
    ./board/Exception/Systick/: Systick_base.c
    ./board/Delay/: Delay_Base.c
  group shell
    ../../../../components/shell/: msh.c msh_cmd.c shell.c
  group boot
    ../../../../board/arm/cortex-m3/: cpuport.c startup_stm32f10x_hd.s context_rvds.S
  group fault_handler
    ./board/Exception/ErrorHandler/: fault_handler.c
  group ipc
    ../../../../kernel/: sem.c mailbox.c
  group lib
    ../../../../lib/list/: list.c
    ../../../../lib/ringbuffer/: kfifo.c
    ../../../../lib/: kservice.c
